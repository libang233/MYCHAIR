# Keil uVision project mchair.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5410AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x27FF) CLOCK(45000000)
  output: mchair +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Src
  group User
    ../Src/: main.c Serial.c Timer.c motor.c
